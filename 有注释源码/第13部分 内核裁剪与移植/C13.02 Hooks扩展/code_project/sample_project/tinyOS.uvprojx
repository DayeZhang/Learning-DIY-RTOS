# Keil uVision project tinyOS.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: tinyOS
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ./Source/: main.c switch.c tinyOS.h tBitmap.c tLib.h tConfig.h tList.c app.c tCpu.c tTask.c tTime.c tEvent.c tSem.c tMBox.c tMemBlock.c tFlagGroup.c tMutex.c tTimer.c tHooks.c
software components: CMSIS:CORE 4.3.0, Device:GPIO 1.3, Device:Startup 1.0.0
